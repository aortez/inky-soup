# Use minimal interfaces file - NetworkManager handles network config.
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
