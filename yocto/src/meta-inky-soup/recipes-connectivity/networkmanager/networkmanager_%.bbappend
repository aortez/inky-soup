# Enable nmtui (curses-based UI) for NetworkManager.
# Not enabled by default in meta-networking.
PACKAGECONFIG:append = " nmtui"
